options:
  parameters:
    generate_options: qt_gui
    id: fg_tp16_001
    output_language: python
    title: FG-TP16-001
  states: {}

blocks:
- name: correction
  id: variable_qtgui_entry
  parameters:
    gui_hint: 2,0,1,2
    label: '"Correction (PPM)"'
    type: int
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: '"Tuned Frequency (Hz)"'
    start: 87.5e6
    step: 0.1e6
    stop: 108e6
    value: 100e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: '"Tuner Gain (dB)"'
    start: '0'
    step: '0.1'
    stop: '49.6'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: chute
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: 3,1,1,1
    int_max: '-20'
    int_min: '-110'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: recepteur
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: '""'
    freq_correction: correction
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: spectre
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 3,0,1,1
    label: '"Relative Gain"'
    name: '"Spectrum"'
    type: complex
    units: '"dB"'
    ymax: '-20'
    ymin: '-110'
  states: {}

connections:
- [recepteur, '0', chute, '0']
- [recepteur, '0', spectre, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
