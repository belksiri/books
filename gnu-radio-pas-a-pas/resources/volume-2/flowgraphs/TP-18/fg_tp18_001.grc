options:
  parameters:
    generate_options: qt_gui
    id: fg_tp18_001
    output_language: python
    title: FG-TP18-001
  states: {}

blocks:
- name: decim_bande
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: '"Tuned Frequency (Hz)"'
    start: 87.5e6
    step: 0.1e6
    stop: 108e6
    value: 100e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: '"Tuner Gain (dB)"'
    start: '0'
    step: '0.1'
    stop: '49.6'
    value: '30'
  states: {}
- name: largeur_station
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: taps_station
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, largeur_station, largeur_station / 5)
  states: {}
- name: fichier
  id: blocks_file_sink
  parameters:
    file: '"enregistrement-fc100M-fe480k.cfile"'
    type: complex
  states: {}
- name: recepteur
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: '""'
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: selection
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decim_bande
    samp_rate: samp_rate
    taps: taps_station
    type: ccf
  states: {}

connections:
- [recepteur, '0', selection, '0']
- [selection, '0', fichier, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
