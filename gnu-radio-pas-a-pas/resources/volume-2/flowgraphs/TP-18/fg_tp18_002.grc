options:
  parameters:
    generate_options: qt_gui
    id: fg_tp18_002
    output_language: python
    title: FG-TP18-002
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: chute
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,1,1,1
    int_max: '-20'
    int_min: '-110'
    name: '"File Waterfall"'
    type: complex
  states: {}
- name: frein
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lecture
  id: blocks_file_source
  parameters:
    file: '"enregistrement-fc100M-fe480k.cfile"'
    repeat: 'True'
    type: complex
  states: {}
- name: spectre
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,1
    label: '"Relative Gain"'
    name: '"File Spectrum"'
    type: complex
    units: '"dB"'
    ymax: '-20'
    ymin: '-110'
  states: {}

connections:
- [frein, '0', chute, '0']
- [frein, '0', spectre, '0']
- [lecture, '0', frein, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
