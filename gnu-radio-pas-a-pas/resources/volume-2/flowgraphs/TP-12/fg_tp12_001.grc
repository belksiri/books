options:
  parameters:
    generate_options: qt_gui
    id: fg_tp12_001
    output_language: python
    title: FG-TP12-001
  states: {}

blocks:
- name: cadence_fichier
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '147'
  states: {}
- name: excursion
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: '"Excursion (Hz)"'
    start: '1000'
    step: '500'
    stop: '8000'
    value: '5000'
  states: {}
- name: f_max
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '160'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: '"Volume"'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.2'
  states: {}
- name: channel
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0'
    seed: '0'
    taps: '[1.0 + 0.0j]'
  states: {}
- name: demoduler
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*excursion)
  states: {}
- name: desaccentuer
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: importer_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: level
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: limiter
  id: low_pass_filter
  parameters:
    cutoff_freq: f_max
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: moduler
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*excursion/samp_rate
  states: {}
- name: recadrer
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: interp
    type: fff
  states: {}
- name: son
  id: blocks_wavfile_source
  parameters:
    file: '"book-audio.wav"'
    repeat: 'True'
  states: {}
- name: sortie_son
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: temps
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    name: '"Audio demodule"'
    size: '480'
    srate: samp_rate
    type: float
  states: {}

connections:
- [channel, '0', demoduler, '0']
- [demoduler, '0', desaccentuer, '0']
- [desaccentuer, '0', level, '0']
- [level, '0', sortie_son, '0']
- [level, '0', temps, '0']
- [limiter, '0', moduler, '0']
- [moduler, '0', channel, '0']
- [recadrer, '0', limiter, '0']
- [son, '0', recadrer, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
