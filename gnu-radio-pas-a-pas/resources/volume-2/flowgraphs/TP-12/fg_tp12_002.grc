options:
  parameters:
    generate_options: qt_gui
    id: fg_tp12_002
    output_language: python
    title: FG-TP12-002
  states: {}

blocks:
- name: cadence_fichier
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '147'
  states: {}
- name: excursion
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: '"Excursion (Hz)"'
    start: '1000'
    step: '500'
    stop: '8000'
    value: '5000'
  states: {}
- name: f_max
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '160'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: debit
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: importer_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: limiter
  id: low_pass_filter
  parameters:
    cutoff_freq: f_max
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: moduler
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*excursion/samp_rate
  states: {}
- name: recadrer
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: interp
    type: fff
  states: {}
- name: son
  id: blocks_wavfile_source
  parameters:
    file: '"book-audio.wav"'
    repeat: 'True'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: '"The FM signal"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}

connections:
- [debit, '0', spectrum, '0']
- [limiter, '0', moduler, '0']
- [moduler, '0', debit, '0']
- [recadrer, '0', limiter, '0']
- [son, '0', recadrer, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
