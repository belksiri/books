options:
  parameters:
    generate_options: qt_gui
    id: fg_tp17_001
    output_language: python
    title: FG-TP17-001
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: decim_audio
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decim_bande
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: '"Tuned Frequency (Hz)"'
    start: 87.5e6
    step: 0.1e6
    stop: 108e6
    value: 100e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: '"Tuner Gain (dB)"'
    start: '0'
    step: '0.1'
    stop: '49.6'
    value: '30'
  states: {}
- name: largeur_station
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: '"Offset to Station (Hz)"'
    start: '-1e6'
    step: 1e4
    stop: 1e6
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate * 40
  states: {}
- name: taps_station
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, largeur_station, largeur_station / 5)
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,2
    label: '"Volume"'
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: carte_son
  id: audio_sink
  parameters:
    device_name: '""'
    samp_rate: audio_rate
  states: {}
- name: demodulation
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate / decim_bande
  states: {}
- name: level
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: recepteur
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: '""'
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: selection
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim_bande
    samp_rate: samp_rate
    taps: taps_station
    type: ccf
  states: {}
- name: vers_audio
  id: rational_resampler_xxx
  parameters:
    decim: decim_audio
    interp: '1'
    type: fff
  states: {}

connections:
- [demodulation, '0', vers_audio, '0']
- [level, '0', carte_son, '0']
- [recepteur, '0', selection, '0']
- [selection, '0', demodulation, '0']
- [vers_audio, '0', level, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
