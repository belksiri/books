options:
  parameters:
    generate_options: qt_gui
    id: fg_ch34_001
    output_language: python
    title: FG-CH34-001
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: '"Tuned Frequency (Hz)"'
    start: 87.5e6
    step: 0.1e6
    stop: 108e6
    value: 100e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: '"Tuner Gain (dB)"'
    start: '0'
    step: '0.1'
    stop: '49.6'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: recepteur
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: '""'
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: spectre
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,1
    label: '"Relative Gain"'
    name: '"Received Spectrum"'
    type: complex
    units: '"dB"'
    ymax: '-20'
    ymin: '-110'
  states: {}

connections:
- [recepteur, '0', spectre, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
