options:
  parameters:
    generate_options: qt_gui
    id: fg_tp08_002
    output_language: python
    title: FG-TP08-002
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: debit
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lecture
  id: blocks_file_source
  parameters:
    file: '"echantillons.iq"'
    repeat: 'True'
    type: complex
  states: {}
- name: spectre
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: '"Spectrum of the replayed file"'
    type: complex
    ymin: '-120'
  states: {}
- name: temps
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: '"I"'
    label2: '"Q"'
    name: '"Relu en complex"'
    size: '512'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [debit, '0', spectre, '0']
- [debit, '0', temps, '0']
- [lecture, '0', debit, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
