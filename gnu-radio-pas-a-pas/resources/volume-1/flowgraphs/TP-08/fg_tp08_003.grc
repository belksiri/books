options:
  parameters:
    generate_options: qt_gui
    id: fg_tp08_003
    output_language: python
    title: FG-TP08-003
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: debit
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: lecture
  id: blocks_file_source
  parameters:
    file: '"echantillons.iq"'
    repeat: 'True'
    type: float
  states: {}
- name: spectre
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,1
    legend: 'False'
    name: '"Spectrum of the wrongly replayed file"'
    type: float
    ymin: '-120'
  states: {}
- name: temps
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,1
    legend: 'False'
    name: '"Relu en float"'
    size: '512'
    srate: samp_rate
    type: float
  states: {}

connections:
- [debit, '0', spectre, '0']
- [debit, '0', temps, '0']
- [lecture, '0', debit, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
