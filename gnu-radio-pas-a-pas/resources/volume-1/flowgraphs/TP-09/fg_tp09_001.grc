options:
  parameters:
    generate_options: qt_gui
    id: fg_tp09_001
    output_language: python
    title: FG-TP09-001
  states: {}

blocks:
- name: cadence_fichier
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: cadence_son
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: coupure
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: '"Coupure (Hz)"'
    start: '300'
    step: '100'
    stop: '20000'
    value: '20000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '147'
  states: {}
- name: decim_vue
  id: variable
  parameters:
    value: '4'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '160'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: '"Volume"'
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.2'
  states: {}
- name: niveau
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: pour_la_vue
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: decim_vue
    gain: '1'
    samp_rate: cadence_son
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: recadrer
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: interp
    type: fff
  states: {}
- name: son
  id: blocks_wavfile_source
  parameters:
    file: '"book-audio.wav"'
    repeat: 'True'
  states: {}
- name: sortie_son
  id: audio_sink
  parameters:
    samp_rate: cadence_son
  states: {}
- name: spectre
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: cadence_son/decim_vue
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    name: '"What goes to the sound card"'
    type: float
    ymax: '0'
    ymin: '-120'
  states: {}
- name: telephone
  id: low_pass_filter
  parameters:
    cutoff_freq: coupure
    decim: '1'
    gain: '1'
    samp_rate: cadence_son
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}

connections:
- [niveau, '0', pour_la_vue, '0']
- [niveau, '0', sortie_son, '0']
- [pour_la_vue, '0', spectre, '0']
- [recadrer, '0', telephone, '0']
- [son, '0', recadrer, '0']
- [telephone, '0', niveau, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
